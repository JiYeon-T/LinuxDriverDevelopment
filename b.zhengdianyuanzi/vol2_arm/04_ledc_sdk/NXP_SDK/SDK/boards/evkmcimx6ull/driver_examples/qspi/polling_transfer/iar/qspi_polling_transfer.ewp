# IAR project qspi_polling_transfer.ewp, settings and files
configuration ddr_debug (ARM, debug)
  General.OGChipSelectEditMenu: MCIMX6Y2 NXP MCIMX6Y2
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 50
  General.FPU2: 5
  ICCARM.CCDefines: CPU_MCIMX6Y2DVM05; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; EVK_MCIMX6ULL
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../../../../../../CORTEXA/Include; ../../../../../../devices; ..; ../../../..; ../../../../../../devices/MCIMX6Y2/drivers; ../../../../../../platform/utilities/debug_console; ../../../../../../platform/utilities/debug_console/io; ../../../../../../platform/utilities/debug_console/str; ../../../../../../devices/MCIMX6Y2/utilities; ../../../../../../devices/MCIMX6Y2
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: qspi_polling_transfer.out
  ILINK.IlinkIcfFile: MCIMX6Y2xxx05_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration ddr_release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  group startup
    ../../../../../../devices/MCIMX6Y2/iar/: startup_MCIMX6Y2.s
    ../../../../../../devices/MCIMX6Y2/: system_MCIMX6Y2.c system_MCIMX6Y2.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/MCIMX6Y2/drivers/: fsl_cache.c fsl_cache.h fsl_uart.h fsl_uart.c fsl_clock.h fsl_clock.c fsl_qspi.h fsl_qspi.c fsl_common.h fsl_common.c fsl_iomuxc.h
  group source
    ../: qspi_polling_transfer.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config_ocram.c clock_config.c clock_config.h
  group utilities
    ../../../../../../devices/MCIMX6Y2/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_io.c fsl_io.h fsl_log.c fsl_log.h fsl_str.c fsl_str.h
