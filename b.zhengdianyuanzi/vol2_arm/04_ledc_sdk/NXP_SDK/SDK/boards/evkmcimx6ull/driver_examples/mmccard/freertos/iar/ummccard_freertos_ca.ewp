# IAR project ummccard_freertos_ca.ewp, settings and files
configuration ddr_debug (ARM, debug)
  General.OGChipSelectEditMenu: MCIMX6Y2 NXP MCIMX6Y2
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 50
  General.FPU2: 5
  ICCARM.CCDefines: CPU_MCIMX6Y2DVM05; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; FSL_RTOS_FREE_RTOS; EVK_MCIMX6ULL
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../../../../../../rtos/freertos_9.0.0/Source/portable/IAR/ARM_CA9; ../../../../../../rtos/freertos_9.0.0/Source/include; ../../../../../../CORTEXA/Include; ../../../../../../devices; ..; ../../../..; ../../../../../../rtos/freertos_9.0.0/Source; ../../../../../../middleware/sdmmc_2.1.2/inc; ../../../../../../middleware/sdmmc_2.1.2/src; ../../../../../../middleware/sdmmc_2.1.2/port; ../../../../../../devices/MCIMX6Y2/drivers; ../../../../../../platform/utilities/debug_console; ../../../../../../platform/utilities/debug_console/io; ../../../../../../platform/utilities/debug_console/str; ../../../../../../devices/MCIMX6Y2/utilities; ../../../../../../devices/MCIMX6Y2
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ..; ../../../..
  ILINK.IlinkOutputFile: ummccard_freertos_ca.out
  ILINK.IlinkIcfFile: MCIMX6Y2xxx05_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; CPU_MCIMX6Y2DVM05; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; FSL_RTOS_FREE_RTOS; EVK_MCIMX6ULL
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MCIMX6Y2xxx05_flash.icf
configuration ddr_release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MCIMX6Y2DVM05; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; FSL_RTOS_FREE_RTOS; EVK_MCIMX6ULL
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: MCIMX6Y2xxx05_flash.icf
  group startup
    ../../../../../../devices/MCIMX6Y2/iar/: startup_MCIMX6Y2.s
    ../../../../../../devices/MCIMX6Y2/: system_MCIMX6Y2.c system_MCIMX6Y2.h
  group freertos
    ../../../../../../rtos/freertos_9.0.0/Source/portable/MemMang/: heap_4.c
    ../../../../../../rtos/freertos_9.0.0/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h deprecated_definitions.h
    ../../../../../../rtos/freertos_9.0.0/Source/: croutine.c list.c queue.c tasks.c timers.c event_groups.c
  group freertos/portable
    ../../../../../../rtos/freertos_9.0.0/Source/portable/IAR/ARM_CA9/: port.c portASM.s portASM.h portmacro.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/MCIMX6Y2/drivers/: fsl_gpio.h fsl_gpio.c fsl_cache.c fsl_cache.h fsl_uart.h fsl_uart.c fsl_usdhc.c fsl_usdhc.h fsl_common.h fsl_common.c fsl_iomuxc.h fsl_clock.h fsl_clock.c
  group sdmmc/src
    ../../../../../../middleware/sdmmc_2.1.2/src/: fsl_mmc.c fsl_sdmmc.c
  group sdmmc/port
    ../: fsl_host.c event.c event.h
  group sdmmc/inc
    ../../../../../../middleware/sdmmc_2.1.2/inc/: fsl_card.h fsl_host.h fsl_sdmmc.h fsl_specification.h
  group source
    ../: mmccard_freertos.c FreeRTOSConfig.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config_ocram.c clock_config.c clock_config.h
  group utilities
    ../../../../../../devices/MCIMX6Y2/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_io.c fsl_io.h fsl_log.c fsl_log.h fsl_str.c fsl_str.h
