# IAR project sai_sdma_freertos.ewp, settings and files
configuration ddr_debug (ARM, debug)
  General.OGChipSelectEditMenu: MCIMX6Y2 NXP MCIMX6Y2
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 50
  General.FPU2: 5
  ICCARM.CCDefines: CPU_MCIMX6Y2DVM05; FSL_RTOS_FREE_RTOS; EVK_MCIMX6ULL
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../../../../../rtos/freertos_9.0.0/Source/portable/IAR/ARM_CA9; ../../../../../rtos/freertos_9.0.0/Source/include; ../../../../../platform/components/wm8960; ../../../../../CORTEXA/Include; ../../../../../devices; ..; ../../..; ../../../../../middleware/sdmmc_2.1.2/inc; ../../../../../middleware/sdmmc_2.1.2/src; ../../../../../middleware/sdmmc_2.1.2/port; ../../../../../rtos/freertos_9.0.0/Source; ../../../../../devices/MCIMX6Y2/drivers; ../../../../../middleware/fatfs_0.12c/src/fsl_sd_disk; ../../../../../platform/utilities/debug_console; ../../../../../platform/utilities/debug_console/io; ../../../../../platform/utilities/debug_console/str; ../../../../../devices/MCIMX6Y2/utilities; ../../../../../middleware/fatfs_0.12c/src; ../../../../../middleware/fatfs_0.12c/src/option; ../../../../../devices/MCIMX6Y2
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ..; ../../..
  ILINK.IlinkOutputFile: sai_sdma_freertos.out
  ILINK.IlinkIcfFile: MCIMX6Y2xxx05_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; CPU_MCIMX6Y2DVM05; FSL_RTOS_FREE_RTOS; EVK_MCIMX6ULL
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MCIMX6Y2xxx05_flash.icf
configuration ddr_release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MCIMX6Y2DVM05; FSL_RTOS_FREE_RTOS; EVK_MCIMX6ULL
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: MCIMX6Y2xxx05_flash.icf
  group startup
    ../../../../../devices/MCIMX6Y2/iar/: startup_MCIMX6Y2.s
    ../../../../../devices/MCIMX6Y2/: system_MCIMX6Y2.c system_MCIMX6Y2.h
  group freertos
    ../../../../../rtos/freertos_9.0.0/Source/portable/MemMang/: heap_4.c
    ../../../../../rtos/freertos_9.0.0/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h deprecated_definitions.h
    ../../../../../rtos/freertos_9.0.0/Source/: croutine.c list.c queue.c tasks.c timers.c event_groups.c
  group freertos/portable
    ../../../../../rtos/freertos_9.0.0/Source/portable/IAR/ARM_CA9/: port.c portASM.s portASM.h portmacro.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MCIMX6Y2/drivers/: fsl_gpio.h fsl_gpio.c fsl_i2c.h fsl_i2c.c fsl_uart.h fsl_uart.c fsl_clock.h fsl_clock.c fsl_usdhc.c fsl_usdhc.h fsl_sai.h fsl_sai.c fsl_sai_sdma.h fsl_sai_sdma.c fsl_sdma.h fsl_sdma.c fsl_common.h fsl_common.c fsl_iomuxc.h
  group codec
    ../: fsl_wm8960.h fsl_wm8960.c
  group sdmmc/port
    ../../freertos_camera/: fsl_host.c event.c event.h
  group sdmmc/src
    ../../../../../middleware/sdmmc_2.1.2/src/: fsl_sd.c fsl_sdmmc.c
  group sdmmc/inc
    ../../../../../middleware/sdmmc_2.1.2/inc/: fsl_card.h fsl_host.h fsl_sdmmc.h fsl_specification.h
  group fatfs/fatfs_include
    ../../../../../middleware/fatfs_0.12c/src/fsl_sd_disk/: fsl_sd_disk.h
    ../../../../../middleware/fatfs_0.12c/src/: integer.h ff.h diskio.h
  group fatfs/fatfs_source
    ../../../../../middleware/fatfs_0.12c/src/fsl_sd_disk/: fsl_sd_disk.c
    ../../../../../middleware/fatfs_0.12c/src/: ff.c diskio.c
  group source
    ../: sai_sdma_freertos.c ffconf.h FreeRTOSConfig.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config_ocram.c clock_config.c clock_config.h
  group utilities
    ../../../../../devices/MCIMX6Y2/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_io.c fsl_io.h fsl_log.c fsl_log.h fsl_str.c fsl_str.h
