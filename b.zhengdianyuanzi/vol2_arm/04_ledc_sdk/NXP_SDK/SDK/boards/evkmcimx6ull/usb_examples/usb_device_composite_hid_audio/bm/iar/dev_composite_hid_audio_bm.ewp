# IAR project dev_composite_hid_audio_bm.ewp, settings and files
configuration ddr_debug (ARM, debug)
  General.OGChipSelectEditMenu: MCIMX6Y2 NXP MCIMX6Y2
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 50
  General.FPU2: 5
  ICCARM.CCDefines: CPU_MCIMX6Y2DVM05; USB_STACK_BM; EVK_MCIMX6ULL
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../../../../../../CMSIS/Include; ../../../../../../CORTEXA/Include; ../../../../../../devices; ../../../../../../platform/drivers; ..; ../../../../../../middleware/usb_1.6.3; ../../../../../../middleware/usb_1.6.3/osa; ../../../../../../middleware/usb_1.6.3/include; ../../../../../../middleware/usb_1.6.3/device; ../../../..; ../../../../../../middleware/usb_1.6.3/phy; ../../../../../../devices/MCIMX6Y2/drivers; ../../../../../../platform/utilities/debug_console; ../../../../../../platform/utilities/debug_console/io; ../../../../../../platform/utilities/debug_console/str; ../../../../../../devices/MCIMX6Y2/utilities; ../../../../../../devices/MCIMX6Y2
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: dev_composite_hid_audio_bm.out
  ILINK.IlinkIcfFile: MCIMX6Y2xxx05_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: _DEBUG=1; CPU_MCIMX6Y2DVM05; USB_STACK_BM; EVK_MCIMX6ULL
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MCIMX6Y2xxx05_flash.icf
configuration ddr_release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: _DEBUG=0; CPU_MCIMX6Y2DVM05; USB_STACK_BM; EVK_MCIMX6ULL
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: MCIMX6Y2xxx05_flash.icf
  group startup
    ../../../../../../devices/MCIMX6Y2/iar/: startup_MCIMX6Y2.s
    ../../../../../../devices/MCIMX6Y2/: system_MCIMX6Y2.c system_MCIMX6Y2.h
  group usb/device/source
    ../: usb_device_ch9.c usb_device_ch9.h
    ../../../../../../middleware/usb_1.6.3/device/: usb_device_dci.c usb_device_dci.h
  group usb/device/source/ehci
    ../../../../../../middleware/usb_1.6.3/device/: usb_device_ehci.c usb_device_ehci.h
    ../../../../../../middleware/usb_1.6.3/include/: usb_ehci.h
  group usb/device/class
    ../: usb_device_class.c usb_device_class.h
  group usb/device/class/audio
    ../: usb_device_audio.c usb_device_audio.h
  group usb/device/class/hid
    ../: usb_device_hid.c usb_device_hid.h
  group usb/device/include
    ../../../../../../middleware/usb_1.6.3/device/: usb_device.h
  group usb/phy
    ../../../../../../middleware/usb_1.6.3/phy/: usb_phy.c usb_phy.h
  group usb/include
    ../../../../../../middleware/usb_1.6.3/include/: usb.h usb_misc.h usb_spec.h
  group drivers
    ../../../../../../devices/MCIMX6Y2/drivers/: fsl_uart.h fsl_uart.c fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_iomuxc.h
  group osa
    ../../../../../../middleware/usb_1.6.3/osa/: usb_osa.h usb_osa_bm.h usb_osa_bm.c
  group sources
    ../: audio_data.c audio_generator.c audio_generator.h composite.c composite.h mouse.c mouse.h usb_device_descriptor.c usb_device_descriptor.h usb_device_config.h usb_audio_config.h
  group utilities
    ../../../../../../devices/MCIMX6Y2/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_io.c fsl_io.h fsl_log.c fsl_log.h fsl_str.c fsl_str.h
  group board
    ../: clock_config_ocram.c board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
